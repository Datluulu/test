## sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000

CONFIG_LOG_DEFAULT_LEVEL=3

CONFIG_ESP_WIFI_SSID="PhuongNhi"
CONFIG_ESP_WIFI_PASSWORD="datnhikhang"
```
